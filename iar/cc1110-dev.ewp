# IAR project cc1110-dev.ewp, settings and files
configuration Debug on CC1110 (8051, debug)
  General.OGChipSelectMenu: CC1110F32 CC1110F32
  ICC8051.CCDefines: chip=1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CODE\PER_TEST\INCLUDE; ..\CODE\LIBRARY\HAL\INCLUDE; ..\CODE\LIBRARY\HAL_BUI\INCLUDE
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  A8051.ADefines: chip=1110
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration Build .hex for CC1110 (8051)
  as the first configuration, except:
configuration Debug on CC2510 (8051, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2510F32 CC2510F32
  ICC8051.CCDefines: chip=2510
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
configuration Build .hex for CC2510 (8051)
  as the first configuration, except:
  General.OGChipSelectMenu: CC2510F32 CC2510F32
  ICC8051.CCDefines: chip=2510
  A8051.ADefines: chip=2510
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc2510.xcl
  group (top)
    ../code/cc1110-dev/source/: cc1110_dev_radio.c dma.c globals.c main.c msg_format.c uart.c uart_fsm.c
    ../code/cc1110-dev/source/util/: util_lcd_logo.c
  group hal
    ../code/Library/HAL/source/: hal_adc_mgmt.c hal_power_clk_mgmt.c hal_wait.c
  group hal_bui
    ../code/Library/HAL_BUI/source/: hal_bui_button.c hal_bui_joystick.c hal_bui_lcd.c
